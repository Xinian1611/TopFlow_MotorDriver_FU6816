# Keil uVision project Fortior_FOC_FU68x6.uvproj, settings and files
target Fortior_FOC_FU68x6 (MCS-51)
  device: FU6866 Fortior Tech
  cpu: IRAM(0-0xFF) CLOCK(24000000)
  output: Fortior_FOC_FU68x6 +hex
  AfterMake: powershell -NoProfile -ExecutionPolicy Bypass -File ".\hex2bin.ps1"
  c flags: Optimize=8 SizeSpeed=1
  c misc: NOINTVECTOR
  c include: ..\User\include;..\FU68xx_Hardware_Driver\Include;..\User\source\IAP;..\User\source\RingBuffer
  asm include: ..\User\include;..\FU68xx_Hardware_Driver\Include
  link misc: REMOVEUNUSED
  group Application
    ../User/source/Application/: main.c AddFunction.c Interrupt.c CanMin.c
    ../User/include/: Customer.h Protect.h Parameter.h SquStart.h
  group Function
    ../User/source/Function/: MotorControl.c MotorControlFunction.c MotorProtect.c RSDDetect.c BEMFDetect.c SLEEP.c SquStart.LIB
  group HardWare
    ../User/source/Hardware/: ADC.c AMP.c CMP.c CRC.c DMA.c DRIVER.c GPIO.c PIInit.c SPI.c TIMER.c UART.c TSD.c SMDU.c Lin.c CAN.c FU68xx_6_Flash.c WDT.c
  group FU68XX_Hardware_Driver
    ../User/source/Application/: STARTUP_APP1800.A51
  group Document
    ../: README.md
  group IAP
    ../User/source/IAP/: IapApp.c
