# Keil uVision project Boot_FU68x6.uvproj, settings and files
target Boot_FU68x6 (MCS-51)
  device: FU6866 Fortior Tech
  cpu: IRAM(0-0xFF) CLOCK(24000000)
  output: Boot_FU68x6 +hex
  AfterMake: powershell -ExecutionPolicy Bypass -NoProfile -File ".\hex2bin.ps1"
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Boot;..\FU68xx_Hardware_Driver\Include
  group Boot
    ../Boot/: boot_can.c boot_flash.c can_bootloader.c crc16.c main.c Robert_EEPROM.c STARTUP.A51
    ./: param.a51
